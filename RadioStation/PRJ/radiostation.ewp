# IAR project radiostation.ewp, settings and files
configuration Debug (ARM, debug)
  General.OGChipSelectEditMenu: STM32F103xC ST STM32F103xC
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Normal.h
  General.CoreVariant: 38
  General.FPU2: 0
  ICCARM.CCDefines: EMB_FLASH; STM32F10X_HD; USE_STDPERIPH_DRIVER
  ICCARM.CCIncludePath2: ..\BSP\; ..\CMSIS\; ..\StdPeriph_Driver\
  ICCARM.CCOptLevel: 1
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 0
  OBJCOPY.OOCOutputFile: radiostation.hex
  ILINK.IlinkOutputFile: radiostation.out
  ILINK.IlinkIcfFile: D:\Ham\RadioStation\PRJ\stm32f10x_flash.icf
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration Release (ARM)
  as the first configuration, except:
  ICCARM.CCDefines: NDEBUG; EMB_FLASH; STM32F10X_HD; USE_STDPERIPH_DRIVER
  ICCARM.CCOptLevel: 3
  group BSP
    ../BSP/: bsp_24lc16.c bsp_24lc16.h bsp_ad9834.c bsp_ad9834.h bsp_ad9951.c bsp_ad9951.h bsp_adc.c bsp_adc.h bsp_baud.c bsp_baud.h bsp_board.c bsp_board.h bsp_dac.c bsp_delay.c bsp_delay.h bsp_iambic_keyer.c bsp_iambic_keyer.h bsp_kenwood.c bsp_kenwood.h bsp_key.c bsp_key.h bsp_oled.c bsp_oled.h bsp_oled_api.c bsp_oled_api.h bsp_pwm.c bsp_pwm.h bsp_receive_att.c bsp_receive_att.h bsp_timer.c bsp_timer.h bsp_transmit_power.c bsp_transmit_power.h bsp_usart.c bsp_usart.h bsp_vol.c bsp_vol.h i2c.c i2c.h zk.h
  group CMSIS
    ../CMSIS/: startup_stm32f10x_hd.s stm32f10x.h system_stm32f10x.c
  group PRJ
    ./: main.c
  group StdPeriph_Driver
    ../StdPeriph_Driver/: misc.c misc.h stm32f10x_adc.c stm32f10x_adc.h stm32f10x_conf.h stm32f10x_dma.c stm32f10x_dma.h stm32f10x_exti.c stm32f10x_exti.h stm32f10x_gpio.c stm32f10x_gpio.h stm32f10x_rcc.c stm32f10x_rcc.h stm32f10x_tim.c stm32f10x_tim.h stm32f10x_usart.c stm32f10x_usart.h
