# IAR project Backup of radiostation.ewp, settings and files
configuration Debug (ARM, debug)
  General.OGChipSelectEditMenu: STM32F10xxC ST STM32F10xxC
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Normal.h
  ICCARM.CCDefines: USE_STDPERIPH_DRIVER; STM32F10X_HD
  ICCARM.CCIncludePath2: ..\BSP\; ..\CMSIS\; ..\StdPeriph_Driver\
  ICCARM.CCOptLevel: 1
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 0
  OBJCOPY.OOCOutputFile: radiostation.srec
  ILINK.IlinkOutputFile: c.out
  ILINK.IlinkIcfFile: stm32f10x_flash.icf
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration Release (ARM)
  as the first configuration, except:
  General.OGChipSelectEditMenu: default None
  ICCARM.CCDefines: NDEBUG
  ICCARM.CCOptLevel: 3
  OBJCOPY.OOCOutputFile: c.srec
  group BSP
    ../BSP/: bsp_board.c bsp_board.h bsp_delay.c bsp_delay.h bsp_oled.c bsp_oled.h
  group CMSIS
    ../CMSIS/: stm32f10x.h system_stm32f10x.c
  group PRJ
    ./: main.c
  group StdPeriph_Driver
    ../StdPeriph_Driver/: stm32f10x_adc.c stm32f10x_adc.h stm32f10x_conf.h stm32f10x_gpio.c stm32f10x_gpio.h stm32f10x_rcc.c stm32f10x_rcc.h stm32f10x_tim.c stm32f10x_tim.h
